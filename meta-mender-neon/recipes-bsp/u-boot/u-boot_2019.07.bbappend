require u-boot-2019.07-common-neon.inc
# MENDER_UBOOT_AUTO_CONFIGURE = "1"
