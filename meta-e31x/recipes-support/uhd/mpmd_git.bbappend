MPM_DEVICE_ni-e31x = "e31x"

RDEPENDS_${PN}_append_ni-e31x-sg1 = " \
    linux-firmware-ni-e31x-sg1-fpga \
"

RDEPENDS_${PN}_append_ni-e31x-sg3 = " \
    linux-firmware-ni-e31x-sg3-fpga \
"
