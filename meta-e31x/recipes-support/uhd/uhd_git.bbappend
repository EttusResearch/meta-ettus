RDEPENDS_${PN}_append_ni-e31x = " uhd-fpga-images-e31x-sg1 \
				   uhd-fpga-images-e31x-sg3 \
				 "

PACKAGECONFIG_ni-e31x = "mpmd liberio"

