CORE_IMAGE_EXTRA_INSTALL_append_ni-e31x = " \
    eeprom-hostname-systemd \
"
