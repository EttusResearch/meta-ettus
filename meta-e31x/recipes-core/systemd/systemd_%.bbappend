PACKAGECONFIG_append_ni-e31x = " networkd resolved"
