FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://boost-1.63.0-fix-python.patch \
"
