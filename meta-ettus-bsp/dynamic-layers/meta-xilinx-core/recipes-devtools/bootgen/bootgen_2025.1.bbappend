FILESEXTRAPATHS:prepend := "${THISDIR}/bootgen-2025.1:"

SRC_URI += "file://0001-Read-header-information-before-reading-partitions.patch"
