ATF_VERSION = "2.6"
SRCREV = "0897efd45ccad29a3dbab610578c70e3a52b2caa"
LIC_FILES_CHKSUM = "file://license.rst;md5=1dd070c98a281d18d9eefd938729b031"

require recipes-bsp/arm-trusted-firmware/arm-trusted-firmware.inc