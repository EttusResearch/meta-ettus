CORE_IMAGE_EXTRA_INSTALL_append_ni-sulfur = " \
    mpmd-tools \
    eeprom-hostname-systemd \
"
