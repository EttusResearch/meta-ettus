do_install_append() {
    rm ${D}${PYTHON_SITEPACKAGES_DIR}/gpiod.a
}
