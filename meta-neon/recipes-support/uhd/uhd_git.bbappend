PACKAGECONFIG_ni-neon = "mpmd liberio"

