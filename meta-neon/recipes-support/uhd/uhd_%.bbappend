PACKAGECONFIG_ni-neon = "mpmd python"
