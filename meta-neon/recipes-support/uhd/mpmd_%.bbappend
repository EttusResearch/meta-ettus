MPM_DEVICE_ni-neon = "e320"

RDEPENDS_${PN}_append_ni-neon = " \
    linux-firmware-ni-neon-fpga \
"
