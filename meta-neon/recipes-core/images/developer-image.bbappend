CORE_IMAGE_EXTRA_INSTALL_append_ni-neon = " \
    eeprom-hostname-systemd \
"
