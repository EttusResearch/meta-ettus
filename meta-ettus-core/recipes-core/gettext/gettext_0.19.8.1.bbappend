FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
    file://0001-ostream.h-styled-ostream.h-Fix-linking.patch \
"
