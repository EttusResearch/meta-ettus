FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Kill-bogus-TYPE_BLOB-marker-type.patch"
