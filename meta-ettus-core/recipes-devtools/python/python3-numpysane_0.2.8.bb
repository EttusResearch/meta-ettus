inherit setuptools3
require python-numpysane.inc

PYPI_SRC_URI = "https://files.pythonhosted.org/packages/72/e8/146515e66780ce2bfef3c0ea02cec4382753075f3656af2192037eca45fc/numpysane-0.28.tar.gz"

S = "${WORKDIR}/numpysane-0.28"

SRC_URI[md5sum] = "a447e34b3ec3c9f65229caf54bcd8a5a"
SRC_URI[sha256sum] = "4131bcebea6ca004fc2ac112c3d5680b9a10cea34f9af8843a56645de1b69fc8"
