inherit setuptools3
require python-rpyc.inc

SRC_URI[md5sum] = "3f1d864da58341ae1477790304f09097"
SRC_URI[sha256sum] = "4b544e57d0f41de48de8886850bd8133cb34f3f0aec01b34e2851e23c439836b"
