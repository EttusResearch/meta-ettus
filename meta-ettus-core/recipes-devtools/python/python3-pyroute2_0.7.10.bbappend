
RDEPENDS:${PN} += "python3-sqlite3"
