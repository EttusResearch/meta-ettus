inherit setuptools3
require python-gnuplotlib.inc

SRC_URI[md5sum] = "0a2c23ba59bafab73a9508dfd6a8e80d"
SRC_URI[sha256sum] = "6b47473aa2ba8e7d0f22b558620854e056494d9a04456b2a744fe88a90cb4465"
