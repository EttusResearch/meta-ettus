require python-unittest-xml-reporting.inc
inherit setuptools3
