PACKAGECONFIG:append = " maintainer-mode"
