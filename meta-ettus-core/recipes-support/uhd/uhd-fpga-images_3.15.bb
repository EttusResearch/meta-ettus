require recipes-support/uhd/uhd_3.15_src.inc
require recipes-support/uhd/uhd-fpga-images.inc
