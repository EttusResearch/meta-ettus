require uhd_4.10.inc
require uhd_4.10_src.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=8255adf1069294c928e0e18b01a16282"
