# GNURadio toolchain
TOOLCHAIN_HOST_TASK = "task-gnuradio-toolchain-host"
TOOLCHAIN_TARGET_TASK = "task-gnuradio-toolchain-target"

require recipes/meta/meta-toolchain.bb
SDK_SUFFIX = "toolchain-gnuradio"

