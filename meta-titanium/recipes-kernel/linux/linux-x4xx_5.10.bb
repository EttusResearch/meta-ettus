KBRANCH = "linux-5.10.y"
SRCREV_ni-titanium = "e97bd1e03e6ef58ec47ee7f085f8c14ed6329cf7"
LINUX_VERSION = "5.10.37"
KBUILD_DEFCONFIG = "x410_defconfig"

require linux-x4xx.inc
require kernel-include-nirio-header.inc
