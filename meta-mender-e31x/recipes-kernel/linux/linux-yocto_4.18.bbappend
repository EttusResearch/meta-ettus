COMPATIBLE_MACHINE_ni-e31x-mender = "ni-e31x-mender-sg3|ni-e31x-mender-sg1"
