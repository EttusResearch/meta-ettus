require u-boot-2019.07-common-e31x.inc
