FILESEXTRAPATHS_prepend_ettus-e300 := "${THISDIR}/base-files:"

dirs755 += " /media/FAT"

