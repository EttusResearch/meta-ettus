FILESEXTRAPATHS_prepend_ettus-e300 := "${THISDIR}/${BPN}:"

