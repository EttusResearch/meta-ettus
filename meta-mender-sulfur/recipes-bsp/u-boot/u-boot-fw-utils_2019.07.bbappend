require u-boot-2019.07-common-sulfur.inc
