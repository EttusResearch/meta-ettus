require u-boot-2018.07-common.inc

MENDER_UBOOT_AUTO_CONFIGURE_ni-sulfur = "0"
