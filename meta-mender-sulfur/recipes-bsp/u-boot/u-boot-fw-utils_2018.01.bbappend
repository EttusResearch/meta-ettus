require u-boot-2018.01-common.inc

MENDER_UBOOT_AUTO_CONFIGURE_ni-sulfur = "0"
