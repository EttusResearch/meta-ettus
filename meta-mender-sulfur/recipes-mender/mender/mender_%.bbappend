SYSTEMD_AUTO_ENABLE:ni-sulfur-mender = "disable"
