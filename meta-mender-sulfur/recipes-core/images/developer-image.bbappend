MENDER_DATA_PART_DIR_append = "${DEPLOY_DIR_IMAGE}/persist"
